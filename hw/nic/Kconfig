## hw/nic/Kconfig
```kconfig
config NIC_PCI_EXPRESS
    bool
    default y if PCI_DEVICES || PCIE_DEVICES
    depends on PCI_EXPRESS && MSI_NONBROKEN
```
